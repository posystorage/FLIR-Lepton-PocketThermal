# Keil uVision project FLIR LWIR.uvprojx, settings and files
target FLIR LWIR (6190000::V6.19::ARMCLANG)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicroM4_DFP.1.0.2
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x28000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: FLIR LWIR +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: ..\APP;..\USER;..\SYS;..\CORE;..\HARDWARE;..\M48x_BSP\Device;..\M48x_BSP\StdDriver\inc;..\M48x_BSP\UsbHostLib\inc;..\thirdparty\fatfs
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x55000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  group USER
    ../USER/: main.c
  group APP
    ../APP/: power_manager.c usb_composite.c usb_uvc.c agc.c color_palette.c image_proc.c lepton_app.c temp_measure.c image_upscale.c storage.c ui.c ui_draw.c ui_menu.c mcu_font.c flir_font_16.c
  group HARDWARE
    ../HARDWARE/: iic.c lp3921.c lcd.c lepton.c key.c uart4.c sdcard.c mpu6050.c
  group fatfs
    ../thirdparty/fatfs/: diskio.c ff.c ffsystem.c ffunicode.c
  group SYS
    ../SYS/: delay.c system_init.c sys_tick.c
  group M48x_BSP_StdDriver
    ../M48x_BSP/StdDriver/src/: clk.c gpio.c sys.c uart.c i2c.c ebi.c bpwm.c sdh.c spi.c timer.c eadc.c usbd.c hsusbd.c
  group CORE
    ../CORE/: system_M480.c startup_M480.s arm_cortexM4lf_math.lib
